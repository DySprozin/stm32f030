<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Pr21v3_MQ3_UART.ewp</path>
  </project>
  <batchBuild/>
</workspace>



# IAR project Pr21v3_MQ3_UART.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: .\inc; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Pr21v3_MQ3_UART.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group src
    src/: main.c
  group src/CMSIS
    src/CMSIS/: system_stm32f0xx.c
  group src/inc
    src/inc/: adc.h def.h stm32f0xx.h system_stm32f0xx.h usart.h
  group src/lib
    src/lib/: adc.c usart.c
  group src/startup
    src/startup/: startup_stm32f0xx.s

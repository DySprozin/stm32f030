<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PR_26_Hall_sensor_bus.ewp</path>
    </project>
    <batchBuild />
</workspace>
